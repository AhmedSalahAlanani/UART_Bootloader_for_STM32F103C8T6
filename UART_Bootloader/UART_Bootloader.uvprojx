# Keil uVision project UART_Bootloader.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: FPEC_program.c GPIO_program.c main.c RCC_program.c SCB_program.c SysTick_program.c UART_program.c UARTBootloader_program.c
  group inc
    ./: BIT_MATH.h FPEC_config.h FPEC_interface.h FPEC_private.h GPIO_config.h GPIO_interface.h GPIO_private.h RCC_config.h RCC_interface.h RCC_private.h SCB_config.h SCB_interface.h SCB_private.h STD_TYPES.h SysTick_config.h SysTick_interface.h SysTick_private.h UART_config.h UART_interface.h UART_private.h UARTBootloader_config.h UARTBootloader_interface.h UARTBootloader_private.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
